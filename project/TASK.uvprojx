# Keil uVision project TASK.uvprojx, settings and files
target TASK (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TASK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\Driver\HardWare\KEY;..\Driver\HardWare\LED;..\Driver\HardWare\OLED;..\Driver\HardWare\RTC;..\Driver\HardWare\SDCARD;..\Driver\HardWare\SPI_FLASH;..\Driver\HardWare\USART;..\Driver\HeaderFiles;..\Driver\Library;..\Driver\Start\CMSIS;..\Driver\Start\Startup;..\Driver\System\ADC;..\Driver\System\TIM6;..\User;..\Driver\Library\GD32F4xx_standard_peripheral\Include;..\Driver\Library\GD32F4xx_standard_peripheral\Source;..\Driver\Start\CMSIS\GD\GD32F4xx\Include;..\Driver\Start\CMSIS\GD\GD32F4xx\Source;..\sysFunction;..\Driver\Fatfs;..\Driver\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Hardware
    ../Driver/HardWare/KEY/: Key.c Key.h
    ../Driver/HardWare/LED/: LED.c LED.h
    ../Driver/HardWare/OLED/: OLED.c OLED.h OLEDfont.h
    ../Driver/HardWare/USART/: USART.c USART.h
    ../Driver/Fatfs/: diskio.c ff.c
  group HeaderFiles
    ../Driver/HeaderFiles/: HeaderFiles.h
  group Start
    ../Driver/Start/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group System
    ../Driver/System/: myDMA.c myDMA.h
  group Library
    ../Driver/Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_crc.c gd32f4xx_dma.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_usart.c
  group CMSIS
    ../Driver/Start/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group sysFunction
    ../sysFunction/: Function.c Function.h bootloader.c bootloader.h
    ../sysfunction/: file_mgr.c file_mgr.h
software components: CMSIS:CORE 5.1.1
